# Keil uVision project 01_ALARM.uvprojx, settings and files
target 01_ALARM (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 01_ALARM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Application;../Common;../FreeRTOS/Inc;../FreeRTOS/Inc/portable;../Interface
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Inc/: FreeRTOSConfig.h
    ../Core/Src/: main.c gpio.c i2c.c rtc.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Common
    ../Common/: Com_Debug.c Com_Debug.h
  group Interface
    ../Interface/: Int_key.c Int_key.h Int_touch.c Int_touch.h Int_Mic.c Int_Mic.h Int_ds18b20.c Int_ds18b20.h Int_buzzer.c Int_buzzer.h Int_oled.c Int_oled.h
  group Application
    ../Application/: App_freeRTOS.c App_freeRTOS.h App_show.c App_show.h App_switch.c App_switch.h
  group FreeRTOS
    ../FreeRTOS/Src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/portable
    ../FreeRTOS/Src/portable/: heap_4.c port.c
software components: CMSIS:CORE 4.3.0
